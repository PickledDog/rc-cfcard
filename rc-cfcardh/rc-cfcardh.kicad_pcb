# Repository PickledDog/rc-cfcard

File README.md:

# rc-cfcard
 Buffered CompactFlash card for RC2014

## Overview
This is my take on an RC2014 CompactFlash adapter card. It incorporates fixes gleaned from discussions within the retrocomputing community, aiming to maximize compatibility with CompactFlash cards old and new.

## Description
This board allows one to add a CompactFlash card to their RC2014 system. Adding non-volatile flash storage like this allows one to run CP/M, via Grant Searle's [CP/M Loader](http://searle.x10host.com/cpm/index.html), Stephen C Cousins' [Small Computer Monitor](https://smallcomputercentral.wordpress.com/small-computer-monitor/), or Wayne Warthen's [RomWBW](https://github.com/wwarthen/RomWBW), other system components permitting. As a general rule, CP/M requires your system be able to boot from ROM, then page it out for RAM (basic memory boards can't do this, pageable ones can).

### Technical details
Interfacing a CompactFlash card to the RC2014 bus is nothing new. Short of doing all access via an 8255 PPI, this generally involves mapping the (ATA-mode) CF address space to I/O addresses 0x10 through 0x17, and connecting 8 of the data lines to the RC2014 databus. However, the fast level transitions of modern CompactFlash are only intended for the short traces between card and interface in a system, and do not play nice with the long paths of the unterminated RC2014 bus.

My approach to handling this was informed by Bill Shen's posts in the [retro-comp Google Group](https://groups.google.com/g/retro-comp). My takeaways from these, were that:
* CS should be asserted a little before IORD and IOWR
* The data line transitions should be limited, either via 100Ω resistors (good), or a 74x245 bus transceiver (better)
* CompactFlash is CMOS (not TTL), so said transceiver should be 74HC (not 74HCT)

With these in mind, the IORD and IOWR signals are set up with a 2-gate delay from the address decoder (which is 74AHCT, to give it a little head start). The CF data lines end at a 74HC245 bus transceiver, from which nice RC2014-friendly level transitions meet the bus. In addition, I *really* wanted to mount the CF socket directly to the board (and skip the IDE-CF adapter). I practiced mounting common SMT CF sockets to boards, and while I am able to do this, the difficulty involved is undeniable. But as luck would have it, I came across a [through-hole CF socket](https://www.mouser.com/ProductDetail/200-CFT12501LDRA01SL) that is readily available. The end result is an all-through-hole board, with no adapters or edge-soldered pin headers.

### Compatibility
The intention is to support **all** CompactFlash memory cards. All cards *should* work - please let me know if you have one that doesn't work with the board. Software-wise, the board is compatible with the CP/M loaders and distributions listed above. The mentioned systems have their own requirements - refer to their documentation for dependencies and instructions. CP/M will only with if you have compatible memory boards - examples are the official RC2014 [RAM](https://rc2014.co.uk/modules/64k-ram/) and [ROM](https://rc2014.co.uk/modules/pageable-rom/) boards, the RC2014 [512K+512K RAM+ROM](https://rc2014.co.uk/modules/512k-rom-512k-ram-module/) board, my [PD101](https://github.com/PickledDog/rc-z80ram) and [PD104](https://github.com/PickledDog/rc-rom) boards, my [PD106](https://github.com/PickledDog/rc-ramrom) board, or Rob Dobsons' [RAMRaider](https://github.com/robdobsn/LinearPagedRAMROM1MB) board. Alternatively, motherboards that have pageable memory systems built-in will work, such as Stephen C Cousins' [SC114](https://smallcomputercentral.wordpress.com/sc114-documentation/), [SC126](https://smallcomputercentral.wordpress.com/sc126-z180-motherboard-rc2014/), and [SC130](https://smallcomputercentral.wordpress.com/sc130-z180-motherboard/). The official 32K RAM, 8K ROM, Switchable ROM, RC2014 Mini/Micro, and boards from the [Classic II](https://rc2014.co.uk/full-kits/rc2014-classic-ii/) kit will *not* work.

## Bus connection
Enhanced bus connections are provided, but the extra pins are solely used to provide stronger ground and power connections. As such, the wider connector is optional, but recommended if you are using an Enhanced backplane.

## Note on assembly
The CF socket lacks metal pins or other mounting tabs, providing only plastic pegs on its underside. Gaps in the pegs are intended for solder to flow into during... I guess wave soldering?

It seems to rely on solder melting and solidifying in the "hook" of the peg. There's no way to feed this solder in from the top, but I had some luck hand-inserting dry solder before pushing the socket down and heating the mounting holes with the iron.

## Part selection
Bill Of Materials and part references are below. If you want the 50-pin RC2014 Enhanced bus connector, you'll need to make it from a 2x40-pin right-angle header and pull out most of the pins from the top row (needle-nose pliers work well). I recommend using gold-plated header for this - I use these ones from [Pololu](https://www.pololu.com/product/2668) or [Sparkfun](https://www.sparkfun.com/products/12792) (these are cheaper than the Mouser listing below).

The specified parts are just the ones I used, and can be substituted as needed - Mouser links provided for convenience and reference.

| Reference | Value | Qty | Mouser link |
| --------- | ----- | --- | ----------- |
| C1-C3 | 100nF ceramic | 3 | [KEMET C315C104M5U5TA](https://www.mouser.com/ProductDetail/C315C104M5U5TA7303) |
| C4 | 10μF ceramic | 1 | [TDK FG18X5R1E106MRT06](https://www.mouser.com/ProductDetail/FG18X5R1E106MRT06) |
| D1 | 3mm red LED | 1 | [Lite-On LTL-4221N](https://www.mouser.com/ProductDetail/LTL-4221N) |
| J1/2 | 2x40 right-angle header | 1 | [3M 2380-5121TG](https://www.mouser.com/ProductDetail/2380-5121TG) |
| J3 | CompactFlash socket | 1 | [Samtec CFT-125-01-L-D-RA-01-SL](https://www.mouser.com/ProductDetail/200-CFT12501LDRA01SL) |
| R1 | 330Ω resistor | 1 | [Yageo CFR-25JT-52-330R](https://www.mouser.com/ProductDetail/CFR-25JT-52-330R) |
| RN1 | Bussed 1kΩ×4 resistor | 1 | [Bourns 4605X-AP1-102LF](https://www.mouser.com/ProductDetail/4605X-AP1-102LF) |
| U1 | 74AHCT138 | 1 | [TI SN74AHCT138N](https://www.mouser.com/ProductDetail/SN74AHCT138N) |
| U2 | 74HCT32 | 1 | [TI SN74HCT32N](https://www.mouser.com/ProductDetail/SN74HCT32N) |
| U3 | 74HC245 | 1 | [TI SN74HC245N](https://www.mouser.com/ProductDetail/SN74HC245N) |

## KiCad design rc-cfcardh/rc-cfcardh.kicad_pcb

File rc-cfcardh/README.md:

# rc-cfcardh
 Buffered CompactFlash card for RC2014, female header version

## Overview
Want something easier to solder, or just prefer the CompactFlash socket to be above the other RC2014 boards? This variant of rc-cfcard uses a female IDE header (and IDE-to-CF adapter) instead of a directly-mounted CF socket. It is otherwise the same as the primary design; refer to [the main project](https://github.com/PickledDog/rc-cfcard) for anything not covered here.

## Part selection
Bill Of Materials and part references are below. The LED and its resistor can be considered optional, since IDE-to-CF adapters usually have an activity LED of their own. Said adapter can be [sourced from eBay](https://www.ebay.com/sch/i.html?_nkw=ide+to+compact+flash+44+pin) - the board is designed for this style of adapter:

| Reference | Value | Qty | Mouser link |
| --------- | ----- | --- | ----------- |
| C1-C3 | 100nF ceramic | 3 | [KEMET C315C104M5U5TA](https://www.mouser.com/ProductDetail/C315C104M5U5TA7303) |
| C4 | 10μF ceramic | 1 | [TDK FG18X5R1E106MRT06](https://www.mouser.com/ProductDetail/FG18X5R1E106MRT06) |
| D1 | 3mm red LED | 1 | [Lite-On LTL-4221N](https://www.mouser.com/ProductDetail/LTL-4221N) |
| J1/2 | 2x40 right-angle header | 1 | [3M 2380-5121TG](https://www.mouser.com/ProductDetail/2380-5121TG) |
| J3 | 2x22 female header (2mm) | 1 | [Samtec SQT-122-01-F-D-RA](https://www.mouser.com/ProductDetail/200-SQT12201FDRA) |
| R1 | 470Ω resistor | 1 | [Yageo CFR-25JT-52-470R](https://www.mouser.com/ProductDetail/CFR-25JT-52-470R) |
| RN1 | Bussed 1kΩ×4 resistor | 1 | [Bourns 4605X-AP1-102LF](https://www.mouser.com/ProductDetail/4605X-AP1-102LF) |
| U1 | 74AHCT138 | 1 | [TI SN74AHCT138N](https://www.mouser.com/ProductDetail/SN74AHCT138N) |
| U2 | 74HCT32 | 1 | [TI SN74HCT32N](https://www.mouser.com/ProductDetail/SN74HCT32N) |
| U3 | 74HC245 | 1 | [TI SN74HC245N](https://www.mouser.com/ProductDetail/SN74HC245N) |

Parts:
C1, C2, C3: 0.1uF; C_Disc_D3.0mm_W1.6mm_P2.50mm
C4: 10uF; C_Disc_D3.8mm_W2.6mm_P2.50mm
D1: LED; LED_D3.0mm
J1: RC2014; PinHeader_1x39_P2.54mm_Vertical
J2: RC2014_Enh; PinHeader_1x10_P2.54mm_Vertical
J3: IDE 44pin; PinSocket_2x22_P2.00mm_Horizontal
R1: 470R; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
RN1: 1k; R_Array_SIP5
U1: 74AHCT138; DIP-16_W7.62mm_LongPads
U2: 74HCT32; DIP-14_W7.62mm_LongPads
U3: 74HC245; DIP-20_W7.62mm_LongPads

Connections:
+5V: C1.1, C2.1, C3.1, C4.1, D1.2 (A), J1.18, J2.2, J3.41, J3.42, RN1.1 (common), U1.16 (VCC), U2.14 (VCC), U3.20 (VCC)
/~ACT: J3.39, R1.1
/~ACT': D1.1 (K), R1.2
/~CS1: J3.38, RN1.4 (R3)
/~PDIAG: J3.34, RN1.3 (R2)
A0: J1.16, J3.35
A1: J1.15, J3.33
A2: J1.14, J3.36
A3: J1.13, U1.1 (A0)
A4: J1.12, U1.2 (A1)
A5: J1.11, U1.3 (A2)
A6: J1.10, U1.4 (E1)
A7: J1.9, U1.5 (E2)
D0: J1.27, U3.2 (A0)
D0': J3.17, U3.18 (B0)
D1: J1.28, U3.3 (A1)
D1': J3.15, U3.17 (B1)
D2: J1.29, U3.4 (A2)
D2': J3.13, U3.16 (B2)
D3: J1.30, U3.5 (A3)
D3': J3.11, U3.15 (B3)
D4: J1.31, U3.6 (A4)
D4': J3.9, U3.14 (B4)
D5: J1.32, U3.7 (A5)
D5': J3.7, U3.13 (B5)
D6: J1.33, U3.8 (A6)
D6': J3.5, U3.12 (B6)
D7: J1.34, U3.9 (A7)
D7': J3.3, U3.11 (B7)
GND: C1.2, C2.2, C3.2, C4.2, J1.17, J2.1, J3.2, J3.19, J3.22, J3.24, J3.26, J3.28, J3.30, J3.40, J3.43, J3.44, U1.8 (GND), U2.1, U2.2, U2.7 (GND), U3.10 (GND)
~CFCS: J3.37, U1.13 (O2), U2.9
~DMACK: J3.29, RN1.2 (R1)
~IOCS: U2.4, U2.8, U2.13, U3.19 (CE)
~IORD: J3.25, U2.6, U3.1 (A->B)
~IOREQ: J1.26, U2.10
~IOWR: J3.23, U2.11
~M1: J1.19, U1.6 (E3)
~RD: J1.25, U2.5
~RESET: J1.20, J3.1
~WR: J1.24, U2.12

Board: 2 copper layers, 99.1 x 49.9 mm, 15 parts (0 on the bottom side), 40 nets.

Other parts of the board:
MNT1, MNT2: MountingHole_2.7mm_M2.5

## KiCad design rc-cfcard.kicad_pcb

Parts:
C1, C2, C3: 0.1uF; C_Disc_D3.0mm_W1.6mm_P2.50mm
C4: 10uF; C_Disc_D3.8mm_W2.6mm_P2.50mm
D1: LED; LED_D3.0mm
J1: RC2014; PinHeader_1x39_P2.54mm_Vertical
J2: RC2014_Enh; PinHeader_1x10_P2.54mm_Vertical
J3: CF Socket; CF_Card_Socket_PTH
R1: 330R; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
RN1: 1k; R_Array_SIP5
U1: 74AHCT138; DIP-16_W7.62mm_LongPads
U2: 74HCT32; DIP-14_W7.62mm_LongPads
U3: 74HC245; DIP-20_W7.62mm_LongPads

Connections:
+5V: C1.1, C2.1, C3.1, C4.1, D1.2 (A), J1.18, J2.2, J3.13 (VCC), J3.38 (VCC), RN1.1 (common), U1.16 (VCC), U2.14 (VCC), U3.20 (VCC)
/~ACT: J3.45 (~DASP), R1.2
/~ACT': D1.1 (K), R1.1
/~CS1: J3.32 (~CS1), RN1.2 (R1)
/~DMACK: J3.44 (~DMACK), RN1.4 (R3)
/~PDIAG: J3.46 (~PDIAG), RN1.5 (R4)
/~WE: J3.36 (~WE), RN1.3 (R2)
A0: J1.16, J3.20 (A0)
A1: J1.15, J3.19 (A1)
A2: J1.14, J3.18 (A2)
A3: J1.13, U1.1 (A0)
A4: J1.12, U1.2 (A1)
A5: J1.11, U1.3 (A2)
A6: J1.10, U1.4 (E1)
A7: J1.9, U1.5 (E2)
D0: J1.27, U3.2 (A0)
D0': J3.21 (D0), U3.18 (B0)
D1: J1.28, U3.3 (A1)
D1': J3.22 (D1), U3.17 (B1)
D2: J1.29, U3.4 (A2)
D2': J3.23 (D2), U3.16 (B2)
D3: J1.30, U3.5 (A3)
D3': J3.2 (D3), U3.15 (B3)
D4: J1.31, U3.6 (A4)
D4': J3.3 (D4), U3.14 (B4)
D5: J1.32, U3.7 (A5)
D5': J3.4 (D5), U3.13 (B5)
D6: J1.33, U3.8 (A6)
D6': J3.5 (D6), U3.12 (B6)
D7: J1.34, U3.9 (A7)
D7': J3.6 (D7), U3.11 (B7)
GND: C1.2, C2.2, C3.2, C4.2, J1.17, J2.1, J3.1 (GND), J3.8 (A10), J3.9 (~ATA_SEL), J3.10 (A9), J3.11 (A8), J3.12 (A7), J3.14 (A6), J3.15 (A5), J3.16 (A4), J3.17 (A3), J3.39 (~CSEL), J3.50 (GND), U1.8 (GND), U2.4, U2.5, U2.7 (GND), U3.10 (GND)
~CFCS: J3.7 (~CS0), U1.13 (O2), U2.2
~IOCS: U2.3, U2.9, U2.12, U3.19 (CE)
~IORD: J3.34 (~IORD), U2.8, U3.1 (A->B)
~IOREQ: J1.26, U2.1
~IOWR: J3.35 (~IOWR), U2.11
~M1: J1.19, U1.6 (E3)
~RD: J1.25, U2.10
~RESET: J1.20, J3.41 (~RESET)
~WR: J1.24, U2.13

Board: 2 copper layers, 99.1 x 49.9 mm, 13 parts (0 on the bottom side), 41 nets.

## Commit log

2020-12-02 Initial commit of rc-cfcard/PD105
2020-12-05 Fix footprint reference
    Fix footprint reference, clean up groundplane routing a little
2020-12-24 Replace resistor network with SMT parts
2021-01-20 Change to through-hole CF socket
2021-01-24 Added README, BOM and pictures
2021-02-10 Re-arranged support chips
    Moved buffer and OR gate so that data traces can be more uniform in length
2021-07-06 Add header/adapter version
2021-07-06 Fix broken images
